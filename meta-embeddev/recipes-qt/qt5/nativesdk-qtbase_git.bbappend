FILESEXTRAPATHS_prepend := "${THISDIR}/qtbase:"
SRC_URI += " file://gccbaseISystem.patch "
